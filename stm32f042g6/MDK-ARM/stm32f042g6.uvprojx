# Keil uVision project stm32f042g6.uvprojx, settings and files
target stm32f042g6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042G6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f042g6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,ARM_MATH_CM0
  c include: ..\Inc;..\MyCode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/User
    ../Src/: main.c stm32f0xx_it.c
  group MAIN
    ../MyCode/: myloop.c mybsplib.c oled.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Device:STM32Cube LL:COMMON 1.7.0, Device:STM32Cube LL:PWR 1.7.0, Device:STM32Cube LL:RCC 1.7.0, Device:STM32Cube LL:UTILS 1.7.0, Device:Startup 1.0.0
